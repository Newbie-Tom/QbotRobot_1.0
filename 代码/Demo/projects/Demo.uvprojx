# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\libraries\CMSIS\CM3\CoreSupport;..\user\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c stm32f10x_it.c delay.c sys.c usart.c oled.c adc.c RGB.c Timer.c HardWare.c mpu6050.c mpuiic.c niming.c pid.c
    ../user/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group lib
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_sdio.c
  group Cmsis
    ../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
